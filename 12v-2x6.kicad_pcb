# Repository eggsampler/12v-2x6-Current-Monitor

File README.md:

# 12v-2x6 Current Monitor

* Designed to sit in a 2.5" SSD slot
* Unobtrusive, out of the way, doesn't need a specific model for a specific GPU
* Isolated comms to PC over internal usb header
* Connections for external thermistors (eg, to monitor GPU plug)
* Connections to daisy chain PC power button to shutdown in emergency

For more information, see the [schematic](https://github.com/eggsampler/12v-2x6-Current-Monitor/blob/main/out/12v-2x6-schematic.pdf) or the [PCB layout](https://github.com/eggsampler/12v-2x6-Current-Monitor/blob/main/out/12v-2x6-pcb.pdf) ([KiCanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2Feggsampler%2F12v-2x6-Current-Monitor))

[3d model](https://3dviewer.net/#model=https://raw.githubusercontent.com/eggsampler/12v-2x6-Current-Monitor/refs/heads/main/out/12v-2x6.wrl)

## KiCad design 12v-2x6.kicad_pcb

Parts:
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
H5, H6: M4; MountingHole_4.3mm_M4
SYM1: Logo_Open_Hardware_Large; OSHW-Symbol_13.4x12mm_SilkScreen
SYM2: SYM_Hot_Large; ISO_7010_W021

Notes on the sheet:
Fan Mounts
5VP / GND1 <------
5V / GND ------>
Board Mounts

Parts:
FB2: FerriteBead_Small; L_0603_1608Metric
J3: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
R29, R30: 5.1k; R_0402_1005Metric
U8: USBLC6-2SC6; SOT-23-6

Connections:
+5V: FB2.2, U8.5 (VBUS); also elsewhere on the board
/Microcontroller/DM: U8.6 (I/O1); also elsewhere on the board
/Microcontroller/DP: U8.4 (I/O2); also elsewhere on the board
/USB/VBUS: FB2.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS)
GND: J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), R29.2, R30.1, U8.2 (GND); also elsewhere on the board
unnamed: J3.A5 (CC1), R30.2
unnamed: J3.B5 (CC2), R29.1
unnamed: J3.A6 (D+), J3.B6 (D+), U8.3 (I/O2)
unnamed: J3.A7 (D-), J3.B7 (D-), U8.1 (I/O1)

Notes on the sheet:
Ferrite Bead should be lower resistance

Parts:
C29, C30: 0.1u; C_0402_1005Metric
U12: ADuM260N1; SOIC-16W_7.5x12.8mm_P1.27mm

Connections:
+5V: C30.1, U12.16 (VDD2); also elsewhere on the board
+5VP: C29.1, U12.1 (VDD1); also elsewhere on the board
/Alert Isolation/ALERT_IN1: U12.7 (VIF); also elsewhere on the board
/Alert Isolation/ALERT_IN2: U12.6 (VIE); also elsewhere on the board
/Alert Isolation/ALERT_IN3: U12.5 (VID); also elsewhere on the board
/Alert Isolation/ALERT_IN4: U12.4 (VIC); also elsewhere on the board
/Alert Isolation/ALERT_IN5: U12.3 (VIB); also elsewhere on the board
/Alert Isolation/ALERT_IN6: U12.2 (VIA); also elsewhere on the board
/Alert Isolation/ALERT_OUT1: U12.10 (VOF); also elsewhere on the board
/Alert Isolation/ALERT_OUT2: U12.11 (VOE); also elsewhere on the board
/Alert Isolation/ALERT_OUT3: U12.12 (VOD); also elsewhere on the board
/Alert Isolation/ALERT_OUT4: U12.13 (VOC); also elsewhere on the board
/Alert Isolation/ALERT_OUT5: U12.14 (VOB); also elsewhere on the board
/Alert Isolation/ALERT_OUT6: U12.15 (VOA); also elsewhere on the board
GND: C30.2, U12.9 (GND2); also elsewhere on the board
GND1: C29.2, U12.8 (GND1); also elsewhere on the board

Notes on the sheet:
INA238 ALERT pin is an open-drain and active-low by default, using fail safe high state as default Use ADuM260N1 so default idle state is high to match INA238

Parts:
C33: 1u; C_0402_1005Metric
C34: 470p; C_0603_1608Metric
C35: 10u; C_0603_1608Metric
U13: MIC5219-3.3YM5; SOT-23-5

Connections:
+3.3V: C35.1, U13.5 (OUT); also elsewhere on the board
+5V: C33.1, U13.1 (IN), U13.3 (EN); also elsewhere on the board
GND: C33.2, C34.2, C35.2, U13.2 (GND); also elsewhere on the board
unnamed: C34.1, U13.4 (BP)

Notes on the sheet:
Using linear regulator not switching for less noise MIC5219 typically 10mV-500mV dropout, heaps of headroom from 5->3.3 500mA should be more than enough for the STM32

Parts:
BZ1: MLT-8530; MagneticBuzzer_CUI_CMT-8504-100-SMT
C20, C36, C37: 0.1u; C_0402_1005Metric
C38: 22u; C_0805_2012Metric
D1: RED; LED_0603_1608Metric
D2: GREEN; LED_0603_1608Metric
D3: BLUE; LED_0603_1608Metric
D4: WHITE; LED_0603_1608Metric
D5: PURPLE; LED_0603_1608Metric
D6: 1N4148W; D_SOD-123
J4, J5: PH 1x02 2.54; PinHeader_1x02_P2.54mm_Horizontal
J6, J7: S2B-PH-K 1x02 P2; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J8: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical; not fitted
JP1, JP2: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
M2: 470531000; FanPinHeader_1x04_P2.54mm_Vertical
Q1: AO3400A; SOT-23
R7, R26, R39, R40, R49: 10k; R_0402_1005Metric
R33, R34, R35, R47, R48: 1k; R_0402_1005Metric
R38: 220R; R_0402_1005Metric
R41, R42, R43, R44, R45: 2.2k; R_0402_1005Metric
R46: 200k; R_0402_1005Metric
R50: 100R; R_0402_1005Metric
R51: 100k; R_0402_1005Metric
SW1: SKRK; SW_Push_SPST_NO_Alps_SKRK
SW2: PCM12; SW_SPDT_PCM12
U9: TLP175A; Toshiba_SOIC-4-6_4.4x3.6mm_P1.27mm
U14: PCA9306; VSSOP-8_2.3x2mm_P0.5mm

Connections:
+3.3V: C37.1, J8.1, JP2.1 (A), R7.2, R39.2, R40.2, R44.2, R45.2, R48.2, SW2.3 (C), U14.2 (VREF1); also elsewhere on the board
+5V: BZ1.1 (+), C38.1, D6.1 (K), JP1.1 (A), M2.2 (+), R46.2; also elsewhere on the board
/Input Output/BOOT: R26.2; also elsewhere on the board
/Input Output/BUZZER: R50.2; also elsewhere on the board
/Input Output/CASE_SW: R38.1; also elsewhere on the board
/Input Output/FAN_PWM: R45.1, U14.4 (SDA1); also elsewhere on the board
/Input Output/FAN_TACHO: R44.1, U14.3 (SCL1); also elsewhere on the board
/Input Output/LED_BLUE: R35.1; also elsewhere on the board
/Input Output/LED_GREEN: R34.1; also elsewhere on the board
/Input Output/LED_RED: R33.1; also elsewhere on the board
/Input Output/NTC1: J6.1, R39.1; also elsewhere on the board
/Input Output/NTC2: J7.1, R40.1; also elsewhere on the board
/Input Output/RESET: C20.1, R7.1, SW1.2; also elsewhere on the board
/Input Output/RX: J8.2; also elsewhere on the board
/Input Output/TX: J8.3; also elsewhere on the board
/Input Output/VERSION: R48.1, R49.2; also elsewhere on the board
/Input Output/VREF2: C36.1, R42.2, R43.2, R46.1, U14.7 (VREF2), U14.8 (EN)
GND: C20.2, C36.2, C37.2, C38.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), J6.2, J7.2, J8.4, M2.1 (-), Q1.2 (S), R49.1, R51.1, SW1.1, SW2.1 (A), U9.3, U14.1 (GND); also elsewhere on the board
unnamed: BZ1.2 (-), D6.2 (A), Q1.3 (D)
unnamed: D1.2 (A), R33.2
unnamed: D2.2 (A), R34.2
unnamed: D3.2 (A), R35.2
unnamed: D4.2 (A), R41.1
unnamed: D5.2 (A), R47.1
unnamed: J4.1, J5.1, U9.6
unnamed: J4.2, J5.2, U9.4
unnamed: JP1.2 (B), R41.2
unnamed: JP2.2 (B), R47.2
unnamed: M2.4 (PWM), R43.1, U14.5 (SDA2)
unnamed: M2.3 (Tacho), R42.1, U14.6 (SCL2)
unnamed: Q1.1 (G), R50.1, R51.2
unnamed: R38.2, U9.1
unnamed: R26.1, SW2.2 (B)

Notes on the sheet:
Status LEDs to give outputs from MCU
Solder jumper to allow disabling the power leds
Hardware version "number" Read by ADC For any future HW revisions SW needs to know about
STM32 boot mode selection switch
UART programming header, not populated by default
Passive buzzer Designed to be driven from IO pins PWM frequencies
Fan circuit to drive fan from 5V usb supply Driven from MCU PWM output Provides tacho input back to MCU
STM32 hardware reset
Isolated case switch headers Designed to daisy chain to motherboard header
10k NTC thermistors via voltage divider to 10k resistors Thermistor type to be software configurable

Parts:
C13, C14, C15, C16, C17: 0.1u; C_0402_1005Metric
C18: 1u; C_0402_1005Metric
C19: 10u; C_0603_1608Metric
C21, C22: 33p; C_0402_1005Metric
C23, C24: 22p; C_0402_1005Metric
FB1: FerriteBead_Small; L_0603_1608Metric
R27, R28: 0; R_0402_1005Metric
U7: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
Y1: 8M YSX530GA 20pF; Crystal_SMD_5032-2Pin_5.0x3.2mm
Y2: 32.768k FC-135 12.5pF; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+3.3V: C13.1, C14.1, C15.1, C16.1, C19.1, FB1.1, U7.1 (VBAT), U7.24 (VDD), U7.36 (VDD), U7.48 (VDD); also elsewhere on the board
/Alert Isolation/ALERT_OUT1: U7.34 (PA13); also elsewhere on the board
/Alert Isolation/ALERT_OUT2: U7.31 (PA10); also elsewhere on the board
/Alert Isolation/ALERT_OUT3: U7.28 (PB15); also elsewhere on the board
/Alert Isolation/ALERT_OUT4: U7.27 (PB14); also elsewhere on the board
/Alert Isolation/ALERT_OUT5: U7.26 (PB13); also elsewhere on the board
/Alert Isolation/ALERT_OUT6: U7.25 (PB12); also elsewhere on the board
/I2C Isolation/SCL2: U7.42 (PB6); also elsewhere on the board
/I2C Isolation/SDA2: U7.43 (PB7); also elsewhere on the board
/Input Output/BOOT: U7.44 (BOOT0); also elsewhere on the board
/Input Output/BUZZER: U7.16 (PA6); also elsewhere on the board
/Input Output/CASE_SW: U7.18 (PB0); also elsewhere on the board
/Input Output/FAN_PWM: U7.37 (PA14); also elsewhere on the board
/Input Output/FAN_TACHO: U7.38 (PA15); also elsewhere on the board
/Input Output/LED_BLUE: U7.13 (PA3); also elsewhere on the board
/Input Output/LED_GREEN: U7.14 (PA4); also elsewhere on the board
/Input Output/LED_RED: U7.15 (PA5); also elsewhere on the board
/Input Output/NTC1: U7.11 (PA1); also elsewhere on the board
/Input Output/NTC2: U7.12 (PA2); also elsewhere on the board
/Input Output/RESET: U7.7 (NRST); also elsewhere on the board
/Input Output/RX: U7.29 (PA8); also elsewhere on the board
/Input Output/TX: U7.30 (PA9); also elsewhere on the board
/Input Output/VERSION: U7.19 (PB1); also elsewhere on the board
/Microcontroller/DM: U7.32 (PA11); also elsewhere on the board
/Microcontroller/DP: U7.33 (PA12); also elsewhere on the board
GND: C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C21.1, C22.1, C23.1, C24.1, U7.8 (VSSA), U7.23 (VSS), U7.35 (VSS), U7.47 (VSS); also elsewhere on the board
unnamed: C22.2, R27.1, Y1.1
unnamed: C24.2, R28.1, Y2.1
unnamed: C23.2, U7.3 (PC14), Y2.2
unnamed: R28.2, U7.4 (PC15)
unnamed: C21.2, U7.5 (PD0), Y1.2
unnamed: R27.2, U7.6 (PD1)
unnamed: C17.1, C18.1, FB1.2, U7.9 (VDDA)

Notes on the sheet:
Ferrite Bead should be higher resistance
YSX530GA 8MHz 20pF Crystal CL=((C1*C2)/(C1+C2)) + Cstray Assume - C1=C2 - Cstray=5pF 20=C/2+5 C=30pF (or 36pF if Cs=2) Pick 33pF as closest standard value
FC-135 32.768kHz 12.5pF CL=((C1*C2)/(C1+C2)) + Cstray Assume - C1=C2 - Cstray=5pF 12.5=C/2+5 C=15pF (or 21pF Cs=2) Pick 22pF as closest standard value

Parts:
R1, R2, R3, R4, R5, R6: 3m; R_Shunt_Vishay_WSKW0612

Connections:
/12V-2x6 Connectors/12V_IN1: R1.4; also elsewhere on the board
/12V-2x6 Connectors/12V_IN2: R2.4; also elsewhere on the board
/12V-2x6 Connectors/12V_IN3: R3.4; also elsewhere on the board
/12V-2x6 Connectors/12V_IN4: R4.4; also elsewhere on the board
/12V-2x6 Connectors/12V_IN5: R5.4; also elsewhere on the board
/12V-2x6 Connectors/12V_IN6: R6.4; also elsewhere on the board
/12V-2x6 Connectors/12V_OUT1: R1.1; also elsewhere on the board
/12V-2x6 Connectors/12V_OUT2: R2.1; also elsewhere on the board
/12V-2x6 Connectors/12V_OUT3: R3.1; also elsewhere on the board
/12V-2x6 Connectors/12V_OUT4: R4.1; also elsewhere on the board
/12V-2x6 Connectors/12V_OUT5: R5.1; also elsewhere on the board
/12V-2x6 Connectors/12V_OUT6: R6.1; also elsewhere on the board
/Current Sensing/CurrentSense1/IN+: R1.3; also elsewhere on the board
/Current Sensing/CurrentSense1/IN-: R1.2; also elsewhere on the board
/Current Sensing/CurrentSense2/IN+: R2.3; also elsewhere on the board
/Current Sensing/CurrentSense2/IN-: R2.2; also elsewhere on the board
/Current Sensing/CurrentSense3/IN+: R3.3; also elsewhere on the board
/Current Sensing/CurrentSense3/IN-: R3.2; also elsewhere on the board
/Current Sensing/CurrentSense4/IN+: R4.3; also elsewhere on the board
/Current Sensing/CurrentSense4/IN-: R4.2; also elsewhere on the board
/Current Sensing/CurrentSense5/IN+: R5.3; also elsewhere on the board
/Current Sensing/CurrentSense5/IN-: R5.2; also elsewhere on the board
/Current Sensing/CurrentSense6/IN+: R6.3; also elsewhere on the board
/Current Sensing/CurrentSense6/IN-: R6.2; also elsewhere on the board

Notes on the sheet:
"Worst" unbalanced case: 13V 13A per pin in 3mR Vdrop = 13*0.003 = 0.039 Pdiss = (13^2)*0.003 = 0.507 39mV @ 507mW (39mV uses almost full accuracy of INA238 +/-40.96 mV @ ADCRANGE = 1) Assuming Rtheta 40C/W Tdelta = 0.507*40 = 20.28 above ambient WSKW0612 rated 1W @ 70*C 1oz or 2oz CU on PCB should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
0b1000001
0b1000100
0b1000110
0b1000101
0b1000000
0b1000010

Parts:
C25, C28: 10u; C_0603_1608Metric
C26, C27: 0.1u; C_0402_1005Metric
U10: B0505ST8-W3; SSO-8_6.8x5.9mm_P1.27mm_Clearance8mm

Connections:
+5V: C25.1, C26.1, U10.3 (VDDP); also elsewhere on the board
+5VP: C27.1, C28.1, U10.6 (VISO), U10.8 (VSEL); also elsewhere on the board
GND: C25.2, C26.2, U10.1 (PDIS), U10.2 (GND1), U10.4 (GND1); also elsewhere on the board
GND1: C27.2, C28.2, U10.5 (GNDISO), U10.7 (GNDISO); also elsewhere on the board

Notes on the sheet:
Translated from datasheet 电源关断管脚，接GND1芯片正常工作，接逻辑高电平，芯片停止工作。 The power shutdown pin - connect it to GND1 for normal operation; connect it to a logic high level to stop the chip from operating. 输出电压选择。将VSEL连接到VISO以获得5 V输出或将VSEL连接到GNDISO以获得3.3 V输出。这个引脚有一个较弱的内部上拉；因此，不要让该引脚悬空。 Output voltage selection -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

Schematic: SHT_TempSense.kicad_sch, 12V-2x6 Current Monitor

Parts:
C39, C40, C41: 0.1u; C_0402_1005Metric
U15, U16, U17: TMP102xxDRL; SOT-563

Connections:
+5VP: C39.1, C40.1, C41.1, U15.4 (ADD0), U15.5 (V+), U16.5 (V+), U17.5 (V+); also elsewhere on the board
/Current Sensing/SCL1: U15.1 (SCL), U16.1 (SCL), U17.1 (SCL); also elsewhere on the board
/Current Sensing/SDA1: U15.6 (SDA), U16.6 (SDA), U17.4 (ADD0), U17.6 (SDA); also elsewhere on the board
GND1: C39.2, C40.2, C41.2, U15.2 (GND), U16.2 (GND), U16.4 (ADD0), U17.2 (GND); also elsewhere on the board

Notes on the sheet:
Placed near the 12v-2x6 connectors to infer close temperature

Schematic: SHT_Connector_12V.kicad_sch, 12V-2x6 Current Monitor

Parts:
J1, J2: 10164279-124121LF

Connections:
/12V-2x6 Connectors/12V_IN1: J1.1 (+12); also elsewhere on the board
/12V-2x6 Connectors/12V_IN2: J1.2 (+12); also elsewhere on the board
/12V-2x6 Connectors/12V_IN3: J1.3 (+12); also elsewhere on the board
/12V-2x6 Connectors/12V_IN4: J1.4 (+12); also elsewhere on the board
/12V-2x6 Connectors/12V_IN5: J1.5 (+12); also elsewhere on the board
/12V-2x6 Connectors/12V_IN6: J1.6 (+12); also elsewhere on the board
/12V-2x6 Connectors/12V_OUT1: J2.6 (+12); also elsewhere on the board
/12V-2x6 Connectors/12V_OUT2: J2.5 (+12); also elsewhere on the board
/12V-2x6 Connectors/12V_OUT3: J2.4 (+12); also elsewhere on the board
/12V-2x6 Connectors/12V_OUT4: J2.3 (+12); also elsewhere on the board
/12V-2x6 Connectors/12V_OUT5: J2.2 (+12); also elsewhere on the board
/12V-2x6 Connectors/12V_OUT6: J2.1 (+12); also elsewhere on the board
/12V-2x6 Connectors/GND_12V_1: J1.7 (GND), J2.12 (GND)
/12V-2x6 Connectors/GND_12V_2: J1.8 (GND), J2.11 (GND)
/12V-2x6 Connectors/GND_12V_3: J1.9 (GND), J2.10 (GND)
/12V-2x6 Connectors/GND_12V_4: J1.10 (GND), J2.9 (GND)
/12V-2x6 Connectors/GND_12V_5: J1.11 (GND), J2.8 (GND)
/12V-2x6 Connectors/GND_12V_6: J1.12 (GND), J2.7 (GND)
/12V-2x6 Connectors/S1: J1.S1, J2.S1
/12V-2x6 Connectors/S2: J1.S2, J2.S2
/12V-2x6 Connectors/S3: J1.S3, J2.S3
/12V-2x6 Connectors/S4: J1.S4, J2.S4

Notes on the sheet:
These are reversed to the inputs on purpose
Amphenol 10164279-124121LF https://www.amphenol-cs.com/product/10164279124121lf.html Rated for 12A (Apparently) 10mR max contact resistance

Schematic: SHT_Isolation_I2C.kicad_sch, 12V-2x6 Current Monitor

Parts:
C31, C32: 0.1u; C_0402_1005Metric
R31, R32, R36, R37: 5.1k; R_0402_1005Metric
U11: ISO1540; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C32.1, R31.2, R32.2, U11.8 (VCC2); also elsewhere on the board
+5VP: C31.1, R36.2, R37.2, U11.1 (VCC1); also elsewhere on the board
/Current Sensing/SCL1: R37.1, U11.2 (SDA1); also elsewhere on the board
/Current Sensing/SDA1: R36.1, U11.3 (SCL1); also elsewhere on the board
/I2C Isolation/SCL2: R32.1, U11.7 (SDA2); also elsewhere on the board
/I2C Isolation/SDA2: R31.1, U11.6 (SCL2); also elsewhere on the board
GND: C32.2, U11.5 (GND2); also elsewhere on the board
GND1: C31.2, U11.4 (GND1); also elsewhere on the board

Notes on the sheet:
SDA and SCL are interchangeable as the internal circuitry for each is identical These connections are swapped for PCB placement reasons ISO1640 is a drop-in replacement
